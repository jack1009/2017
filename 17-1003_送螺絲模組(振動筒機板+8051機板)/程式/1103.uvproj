# Keil uVision project 1103.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78E054D Nuvoton
  cpu: IRAM(0x00-0xFF) IROM(0x0000-0x3FFF) CLOCK(40000000)
  output: 1103_20171122 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
